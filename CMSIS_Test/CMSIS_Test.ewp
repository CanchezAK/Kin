# IAR project CMSIS_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\src; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\inc; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\Drivers; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\Drivers\cmsis; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\Drivers\cmsis\inc; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\Drivers\cmsis\src; C:\Users\EliteBook\Documents\IAR_Projects\CMSIS_Test\Drivers\cmsis\asm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/cmsis/asm
    Drivers/cmsis/asm/: startup_stm32f411xe.s
  group Drivers/cmsis/inc
    Drivers/cmsis/inc/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group Drivers/cmsis/src
    Drivers/cmsis/src/: system_stm32f4xx.c
  group src
    src/: main.c
