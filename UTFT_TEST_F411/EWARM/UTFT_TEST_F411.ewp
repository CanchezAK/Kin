# IAR project UTFT_TEST_F411.ewp, settings and files
configuration UTFT_TEST_F411 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\Users\CanchezAK\Documents\IAR EW for ARM\UTFT_TEST_F411\Drivers\UTFT_TEST\Inc; C:\Users\CanchezAK\Documents\IAR EW for ARM\UTFT_TEST_F411\Drivers\UTFT_TEST\Src; C:\Users\CanchezAK\Documents\IAR EW for ARM\UTFT_TEST_F411\Drivers\UTFT_TEST
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: UTFT_TEST_F411.hex
  ILINK.IlinkOutputFile: UTFT_TEST_F411.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/UTFT_TEST/Inc
    ../Drivers/UTFT_TEST/Inc/: dtostrf.h ILI9486.h itoa.h memorysaver.h pgmspace.h UTFT_Demo.hpp wiring_constants.h WMath.h WString.h
  group Drivers/UTFT_TEST/Src
    ../Drivers/UTFT_TEST/Src/: DefaultFonts.c dtostrf.c ILI9486.cpp itoa.c UTFT_Demo.cpp WMath.cpp WString.cpp
