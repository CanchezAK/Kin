<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UTFT_TEST_F411.ewp</path>
  </project>
  <batchBuild />
</workspace>
