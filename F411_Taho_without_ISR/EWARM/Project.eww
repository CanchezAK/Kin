<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F411_Taho_without_ISR.ewp</path>
  </project>
  <batchBuild />
</workspace>
