<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Enc_F103.ewp</path>
  </project>
  <batchBuild />
</workspace>
